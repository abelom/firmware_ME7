# IAR project ch.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303xC ST STM32F303xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\os\license; ..\..\..\..\os\common\startup\ARMCMx\devices\STM32F3xx; ..\..\..\..\os\common\ext\ARM\CMSIS\Core\include; ..\..\..\..\os\common\ext\ST\STM32F3xx; ..\..\..\..\os\common\ports\ARMCMx; ..\..\..\..\os\common\ports\ARMCMx\compilers\IAR; ..\..\..\..\os\common\oslib\include; ..\..\..\..\os\rt\include; ..\..\..\..\os\hal\osal\rt; ..\..\..\..\os\hal\include; ..\..\..\..\os\hal\boards\ST_STM32F3_DISCOVERY; ..\..\..\..\os\hal\ports\common\ARMCMx; ..\..\..\..\os\hal\ports\STM32\STM32F3xx; ..\..\..\..\os\hal\ports\STM32\LLD\ADCv3; ..\..\..\..\os\hal\ports\STM32\LLD\CANv1; ..\..\..\..\os\hal\ports\STM32\LLD\DMAv1; ..\..\..\..\os\hal\ports\STM32\LLD\EXTIv1; ..\..\..\..\os\hal\ports\STM32\LLD\GPIOv2; ..\..\..\..\os\hal\ports\STM32\LLD\I2Cv2; ..\..\..\..\os\hal\ports\STM32\LLD\RTCv2; ..\..\..\..\os\hal\ports\STM32\LLD\SPIv2; ..\..\..\..\os\hal\ports\STM32\LLD\TIMv1; ..\..\..\..\os\hal\ports\STM32\LLD\USARTv2; ..\..\..\..\os\hal\ports\STM32\LLD\USBv1; ..\..\..\..\os\hal\ports\STM32\LLD\xWDGv1; ..\..\..\..\test\lib; ..\..\..\..\test\rt\source\test; ..\..\..\..\test\oslib\source\test
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..; ..\..\..\..\os\license; ..\..\..\..\os\common\startup\ARMCMx\devices\STM32F3xx; ..\..\..\..\os\common\ports\ARMCMx; ..\..\..\..\os\hal\boards\ST_STM32F3_DISCOVERY
  OBJCOPY.OOCOutputFile: ch.srec
  ILINK.IlinkOutputFile: ch.out
  ILINK.IlinkIcfFile: ch.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  group (top)
    ../: chconf.h halconf.h main.c mcuconf.h
  group os/common/oslib/include
    ../../../../os/common/oslib/include/: chbsem.h chfactory.h chfifo.h chheap.h chmboxes.h chmemcore.h chmempools.h
  group os/common/oslib/src
    ../../../../os/common/oslib/src/: chfactory.c chheap.c chmboxes.c chmemcore.c chmempools.c
  group os/common/port
    ../../../../os/common/ports/ARMCMx/: chcore.c chcore.h chcore_timer.h chcore_v7m.c chcore_v7m.h
    ../../../../os/common/ports/ARMCMx/compilers/IAR/: chcoreasm_v7m.s chtypes.h
  group os/common/startup
    ../../../../os/common/startup/ARMCMx/devices/STM32F3xx/: cmparams.h
    ../../../../os/common/startup/ARMCMx/compilers/IAR/: cstartup.s vectors.s
  group os/hal/board
    ../../../../os/hal/boards/ST_STM32F3_DISCOVERY/: board.c board.h
  group os/hal/include
    ../../../../os/hal/include/: hal.h hal_adc.h hal_buffers.h hal_can.h hal_channels.h hal_dac.h hal_files.h hal_gpt.h hal_i2c.h hal_i2s.h hal_icu.h hal_ioblock.h hal_mac.h hal_mii.h hal_mmc_spi.h hal_mmcsd.h hal_pal.h hal_pwm.h hal_queues.h hal_rtc.h hal_sdc.h hal_serial.h hal_serial_usb.h hal_spi.h hal_st.h hal_streams.h hal_uart.h hal_usb.h hal_usb_cdc.h hal_wdg.h
  group os/hal/lib/streams
    ../../../../os/hal/lib/streams/: chprintf.c chprintf.h memstreams.c memstreams.h
  group os/hal/port
    ../../../../os/hal/ports/STM32/LLD/ADCv3/: hal_adc_lld.c hal_adc_lld.h
    ../../../../os/hal/ports/STM32/LLD/CANv1/: hal_can_lld.c hal_can_lld.h
    ../../../../os/hal/ports/STM32/LLD/DACv1/: hal_dac_lld.c hal_dac_lld.h
    ../../../../os/hal/ports/STM32/LLD/TIMv1/: hal_gpt_lld.c hal_gpt_lld.h hal_icu_lld.c hal_icu_lld.h hal_pwm_lld.c hal_pwm_lld.h hal_st_lld.c hal_st_lld.h stm32_tim.h
    ../../../../os/hal/ports/STM32/LLD/I2Cv2/: hal_i2c_lld.c hal_i2c_lld.h
    ../../../../os/hal/ports/STM32/LLD/SPIv2/: hal_i2s_lld.c hal_i2s_lld.h hal_spi_lld.c hal_spi_lld.h
    ../../../../os/hal/ports/STM32/STM32F3xx/: hal_lld.c hal_lld.h stm32_isr.c stm32_isr.h stm32_rcc.h stm32_registry.h
    ../../../../os/hal/ports/STM32/LLD/GPIOv2/: hal_pal_lld.c hal_pal_lld.h
    ../../../../os/hal/ports/STM32/LLD/RTCv2/: hal_rtc_lld.c hal_rtc_lld.h
    ../../../../os/hal/ports/STM32/LLD/SDMMCv1/: hal_sdc_lld.c hal_sdc_lld.h
    ../../../../os/hal/ports/STM32/LLD/USARTv2/: hal_serial_lld.c hal_serial_lld.h hal_uart_lld.c hal_uart_lld.h
    ../../../../os/hal/ports/STM32/LLD/USBv1/: hal_usb_lld.c hal_usb_lld.h stm32_usb.h
    ../../../../os/hal/ports/STM32/LLD/xWDGv1/: hal_wdg_lld.c hal_wdg_lld.h
    ../../../../os/hal/ports/common/ARMCMx/: nvic.c nvic.h
    ../../../../os/hal/ports/STM32/LLD/DMAv1/: stm32_dma.c stm32_dma.h
  group os/hal/src
    ../../../../os/hal/src/: hal.c hal_adc.c hal_buffers.c hal_can.c hal_dac.c hal_gpt.c hal_i2c.c hal_i2s.c hal_icu.c hal_mac.c hal_mmc_spi.c hal_mmcsd.c hal_pal.c hal_pwm.c hal_queues.c hal_rtc.c hal_sdc.c hal_serial.c hal_serial_usb.c hal_spi.c hal_st.c hal_uart.c hal_usb.c hal_wdg.c
  group os/rt/include
    ../../../../os/rt/include/: ch.h chalign.h chchecks.h chcond.h chcustomer.h chdebug.h chdynamic.h chevents.h chmsg.h chmtx.h chregistry.h chschd.h chsem.h chstats.h chsys.h chsystypes.h chthreads.h chtm.h chtrace.h chvt.h
  group os/rt/src
    ../../../../os/rt/src/: chcond.c chdebug.c chdynamic.c chevents.c chmsg.c chmtx.c chregistry.c chschd.c chsem.c chstats.c chsys.c chthreads.c chtm.c chtrace.c chvt.c
  group test/lib
    ../../../../test/lib/: ch_test.c ch_test.h
  group test/source
    ../../../../test/oslib/source/test/: oslib_test_root.c oslib_test_root.h oslib_test_sequence_001.c oslib_test_sequence_001.h oslib_test_sequence_002.c oslib_test_sequence_002.h oslib_test_sequence_003.c oslib_test_sequence_003.h oslib_test_sequence_004.c oslib_test_sequence_004.h
    ../../../../test/rt/source/test/: rt_test_root.c rt_test_root.h rt_test_sequence_001.c rt_test_sequence_001.h rt_test_sequence_002.c rt_test_sequence_002.h rt_test_sequence_003.c rt_test_sequence_003.h rt_test_sequence_004.c rt_test_sequence_004.h rt_test_sequence_005.c rt_test_sequence_005.h rt_test_sequence_006.c rt_test_sequence_006.h rt_test_sequence_007.c rt_test_sequence_007.h rt_test_sequence_008.c rt_test_sequence_008.h rt_test_sequence_009.c rt_test_sequence_009.h rt_test_sequence_010.c rt_test_sequence_010.h
